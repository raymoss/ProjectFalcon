# IAR project falcon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: C:\Users\ray\Desktop\STM\Template; C:\Users\msheikh\Desktop\STM\Project_Falcon\Include; C:\Users\ray\Desktop\STM\Template\my_library; C:\Users\msheikh\Desktop\STM\Project_Falcon\STM32F4xx_StdPeriph_Driver\inc; C:\Users\msheikh\Desktop\STM\Project_Falcon; C:\Users\msheikh\Desktop\STM\Project_Falcon\my_library; C:\Users\msheikh\Desktop\STM\Project_Falcon\FreeIMU-20121122_1126\libraries\adxl345driver; C:\Users\msheikh\Desktop\STM\Project_Falcon\FreeIMU-20121122_1126\libraries\HMC58X3; C:\Users\msheikh\Desktop\STM\Project_Falcon\FreeIMU-20121122_1126\libraries\itg3200filv05; C:\Users\msheikh\Desktop\STM\Project_Falcon\RF24-master; C:\Users\msheikh\Desktop\STM\Project_Falcon\KalmanFilter; C:\Users\MOHSIN\Desktop\Project_Falcon\STM32F4xx_StdPeriph_Driver\inc; C:\Users\MOHSIN\Desktop\Project_Falcon; C:\Users\MOHSIN\Desktop\Project_Falcon\my_library; C:\Users\MOHSIN\Desktop\Project_Falcon\FreeIMU-20121122_1126\libraries\adxl345driver; C:\Users\MOHSIN\Desktop\Project_Falcon\FreeIMU-20121122_1126\libraries\HMC58X3; C:\Users\MOHSIN\Desktop\Project_Falcon\FreeIMU-20121122_1126\libraries\itg3200filv05; C:\Users\MOHSIN\Desktop\Project_Falcon\KalmanFilter; C:\Users\MOHSIN\Desktop\Project_Falcon\RF24-master; C:\Users\MOHSIN\Desktop\Project_Falcon\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: C:\Users\ray\Desktop\STM\Template
  OBJCOPY.OOCOutputFile: falcon.srec
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkIcfFile: Blinky.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: comms_misc.c filter.c main.c system_stm32f4xx.c
    KalmanFilter/: Kalman.cpp
  group CMSIS
    Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group COMMS_LIBRARY
    RF24-master/: RF24.cpp RF24.h
  group IMU_LIBRARY
    FreeIMU-20121122_1126/libraries/adxl345driver/: ADXL345.cpp ADXL345.h
    FreeIMU-20121122_1126/libraries/HMC58X3/: HMC58X3.cpp HMC58X3.h
    FreeIMU-20121122_1126/libraries/itg3200filv05/: ITG3200.cpp ITG3200.h
  group My_library
    my_library/: motor_control.c my_i2c.h my_i2c_modified.c my_spi.c my_spi.h usart_print.c usart_print.h
  group ST
    ./: startup_stm32f4xx.s
  group STM_STD_LIBRARY
    STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
