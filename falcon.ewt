<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\Include\arm_common_tables.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\arm_math.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\core_cm0.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\core_cm3.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\core_cm4.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\core_cm4_simd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\core_cmFunc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\core_cmInstr.h</name>
    </file>
  </group>
  <group>
    <name>COMMS_LIBRARY</name>
    <file>
      <name>$PROJ_DIR$\RF24-master\RF24.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\RF24-master\RF24.h</name>
    </file>
  </group>
  <group>
    <name>IMU_LIBRARY</name>
    <file>
      <name>$PROJ_DIR$\FreeIMU-20121122_1126\libraries\adxl345driver\ADXL345.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeIMU-20121122_1126\libraries\adxl345driver\ADXL345.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeIMU-20121122_1126\libraries\HMC58X3\HMC58X3.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeIMU-20121122_1126\libraries\HMC58X3\HMC58X3.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeIMU-20121122_1126\libraries\itg3200filv05\ITG3200.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeIMU-20121122_1126\libraries\itg3200filv05\ITG3200.h</name>
    </file>
  </group>
  <group>
    <name>My_library</name>
    <file>
      <name>$PROJ_DIR$\my_library\motor_control.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my_library\my_i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my_library\my_i2c_modified.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my_library\my_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my_library\my_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my_library\usart_print.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my_library\usart_print.h</name>
    </file>
  </group>
  <group>
    <name>ST</name>
    <file>
      <name>$PROJ_DIR$\startup_stm32f4xx.s</name>
    </file>
  </group>
  <group>
    <name>STM_STD_LIBRARY</name>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
    </file>
  </group>
  <file>
<<<<<<< HEAD
    <name>$PROJ_DIR$\comms_misc.c</name>
  </file>
  <file>
=======
>>>>>>> 5f8c2723cf665d7de0e477ed6e57f36b3f055238
    <name>$PROJ_DIR$\filter.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\KalmanFilter\Kalman.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\system_stm32f4xx.c</name>
  </file>
</project>


